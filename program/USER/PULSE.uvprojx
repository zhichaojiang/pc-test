# Keil uVision project PULSE.uvprojx, settings and files
target pulse (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pulse +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\modbus\include;..\modbus\port;..\modbus\rtu;..\modbus\ascii;..\modbus\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start_code
    ../CMSIS/Startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c led.c read_key.c sw_face.c stm32f10x_it.c SysTick.c iwdg.c key_press.c adc.c tim4_pwm.c high_control.c JLX12864G.c
    ../FWlib/src/: eeprom.c
  group FWLIB
    ../FWlib/src/: STM32_Init.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../FWlib/src/: misc.c
